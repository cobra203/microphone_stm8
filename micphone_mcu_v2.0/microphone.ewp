# IAR project microphone.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: user\inc; lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: microphone.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group lib
    user/inc/: button.h cc85xx_button.h cc85xx_ehif.h cc85xx_ehif_host_ctrl.h cc85xx_host_ops.h mic_led.h stm8s_common.h stm8s_conf.h stm8s_debug.h stm8s_it.h stm8s_led.h stm8s_timer.h
    lib/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_spi.h stm8s_tim4.h stm8s_wwdg.h
  group src
    user/src/: button.c cc85xx_button.c cc85xx_ehif.c cc85xx_ehif_host_ctrl.c cc85xx_host_ops.c main.c mic_led.c stm8s_debug.c stm8s_it.c stm8s_led.c stm8s_timer.c
    lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_wwdg.c
